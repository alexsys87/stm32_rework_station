<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\stm32_rework_station.ewp</path>
    </project>
    <batchBuild />
</workspace>
