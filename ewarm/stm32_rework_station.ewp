# IAR project stm32_rework_station.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB
  ICCARM.CCIncludePath2: ..\app; ..\bsp; ..\cmsis\device
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32_rework_station.srec
  ILINK.IlinkOutputFile: stm32_rework_station.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F103xB; NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../app/: main.c pid.c station.c temperature.c ui.c
  group bsp
    ../bsp/: adc.c board.c clock.c fault_handlers.c max7219.c phase_control.c
  group cmsis
    ../cmsis/device/: startup_stm32f103xb.s system_stm32f1xx.c
